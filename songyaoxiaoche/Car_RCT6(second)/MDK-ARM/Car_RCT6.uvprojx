# Keil uVision project Car_RCT6.uvprojx, settings and files
target Car_RCT6 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: Car_RCT6 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Drivers/CMSIS/Include; ..\User\bsp_debug; ..\User\GraySensor; ..\User\menu; ..\User\Motor; ..\User\OLED; ..\User\openmv; ..\User\pid; ..\User; ..\User\system; ..\User\MPU6050; ..\User\MPU6050\eMPL; ..\User\bsp_debug; ..\User\BlueTooth; ..\User\LED; ..\User\Control
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group HardWare
    ../User/GraySensor/: bsp_graySensor.c
    ../User/menu/: menu.c bsp_key.c
    ../User/Motor/: encoder.c
    ../User/OLED/: OLED.c
    ../User/openmv/: openmv.c
    ../User/pid/: bsp_pid.c
    ../User/system/: bsp_sys.h bsp_delay.c
    ../User/BlueTooth/: bsp_BlueTooth.c
    ../User/bsp_debug/: Fire_protocol.c
    ../User/Control/: control.c
    ../User/LED/: bsp_led.c
software components: CMSIS:CORE 4.3.0
